# Keil uVision project EBF_RA6M5.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA6M5BH3CFC Renesas
  pack: Renesas.RA_DFP.4.0.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: EBF_RA6M5 +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "4.0.0" -nosplash --gensmartbundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 wLevel=1
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\src;..\..\..\catOS\include;..\..\..\catOS\bsp\interface;..\..\..\catOS\bsp\interface\drivers;..\..\..\catOS\src\component\cat_device;..\..\..\catOS\src\component\cat_shell;..\..\..\catOS\src\component\cat_stdio;..\..\..\catOS\src\component\cat_string;..\..\..\catOS\src\component\mem_rw;..\..\..\catOS\src\core\idle_task;..\..\..\catOS\src\core\init;..\..\..\catOS\src\core\interrupt;..\..\..\catOS\src\core\schedule;..\..\..\catOS\src\core\schedule\basic_task;..\..\..\catOS\src\core\schedule\static_prio_sched;..\..\..\catOS\src\core\support;..\..\..\catOS\test;..\..\..\catOS\bsp\arch\cortex_m33\board\ra6m5_fire\drivers;..\..\..\third_party\cm_backtrace;..\..\..\third_party\cm_backtrace\Languages\zh-CN
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group catOS/bsp
    ../../../catOS/bsp/arch/cortex_m33/board/ra6m5_fire/drivers/pin/: cat_drv_pin.c
    ../../../catOS/bsp/arch/cortex_m33/libcpu/: cpu_port.c contex.s pendsv.c switch_to_first.c
    ../../../catOS/bsp/arch/cortex_m33/board/ra6m5_fire/drivers/uart/: cat_drv_uart.c
    ../../../catOS/bsp/arch/cortex_m33/board/ra6m5_fire/port/armcc/: port.c
  group catOS/src
    ../../../catOS/src/component/cat_device/: cat_device.c
    ../../../catOS/src/component/cat_shell/: cat_shell.c cat_shell_cmds.c cat_shell_port.c
    ../../../catOS/src/component/cat_stdio/: cat_stdio.c
    ../../../catOS/src/component/cat_string/: cat_string.c
    ../../../catOS/src/component/mem_rw/: mem_rw.c
    ../../../catOS/src/core/idle_task/: cat_idle.c
    ../../../catOS/src/core/init/: cat_init.c
    ../../../catOS/src/core/interrupt/: cat_intr.c
    ../../../catOS/src/core/schedule/basic_task/: cat_basic_task.c
    ../../../catOS/src/core/schedule/static_prio_sched/: cat_bitmap.c cat_sp_task.c
    ../../../catOS/src/core/support/: cat_list.c cat_ringbuffer.c
    ../../../catOS/test/: test_cat_string.c
    ../../../catOS/src/core/schedule/: cat_task.c
  group third_party/cm_backtrace
    ../../../third_party/cm_backtrace/: cm_backtrace.c
    ../../../third_party/cm_backtrace/fault_handler/gcc/: cmb_fault.S
software components: Flex Software:RA Configuration 1.0.0
