# Keil uVision project keil_c8t6_gnu_demo.uvprojx, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: keil_c8t6_gnu_demo
  group user
    ../../user/: main.c
    ../../user/bsp/board_led/: bsp_board_led.c
  group catos_bsp
    ../../catOS/bsp/stm32f103c8t6_min/drivers/uart/: cat_drv_uart.c
    ../../catOS/bsp/stm32f103c8t6_min/port/gnu/: catos_start.s port.c port_asm.s
  group catos_src_core
    ../../catOS/src/core/idle_task/: cat_idle.c
    ../../catOS/src/core/init/: cat_init.c
    ../../catOS/src/core/interrupt/: cat_intr.c
    ../../catOS/src/core/schedule/basic_task/: cat_basic_task.c
    ../../catOS/src/core/schedule/static_prio_sched/: cat_bitmap.c cat_sp_task.c
    ../../catOS/src/core/support/: cat_list.c
  group catos_src_component
    ../../catOS/src/component/cat_device/: cat_device.c
    ../../catOS/src/component/cat_shell/: cat_shell.c cat_shell_cmds.c cat_shell_port.c
    ../../catOS/src/component/cat_stdio/: cat_stdio.c
    ../../catOS/src/component/cat_string/: cat_string.c
    ../../catOS/src/component/mem_rw/: mem_rw.c
  group HAL_LIB
    ../../catOS/bsp/stm32f103c8t6_min/Libraries/STM32F1xx_HAL_Driver/: stm32f1xx_it.c system_stm32f1xx.c
    ../../catOS/bsp/stm32f103c8t6_min/Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
