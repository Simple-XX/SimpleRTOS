# Keil uVision project demo_vet6_keil.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo_vet6_keil_gnu
  group catOS/bsp
    ../../../catOS/bsp/arch/cortex_m3/board/stm32f103vet6_fire/drivers/pin/: cat_drv_pin.c
    ../../../catOS/bsp/arch/cortex_m3/board/stm32f103vet6_fire/drivers/uart/: cat_drv_uart.c
    ../../../catOS/bsp/arch/cortex_m3/board/stm32f103vet6_fire/port/gcc/: catos_start.s port.c
    ../../../catOS/bsp/arch/cortex_m3/libcpu/: contex.s cpu_port.c
  group user
    ../user/: main.c
  group HAL_Driver
    ../../../catOS/bsp/Libraries/STM32F1xx_HAL_Driver/: stm32f1xx_it.c system_stm32f1xx.c
    ../../../catOS/bsp/Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_exti.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c
  group catOS/src
    ../../../catOS/src/component/cat_device/: cat_device.c
    ../../../catOS/src/component/cat_shell/: cat_shell.c cat_shell_cmds.c cat_shell_port.c
    ../../../catOS/src/component/cat_stdio/: cat_stdio.c
    ../../../catOS/src/component/cat_string/: cat_string.c
    ../../../catOS/src/component/mem_rw/: mem_rw.c
    ../../../catOS/src/core/idle_task/: cat_idle.c
    ../../../catOS/src/core/init/: cat_init.c
    ../../../catOS/src/core/interrupt/: cat_intr.c
    ../../../catOS/src/core/schedule/basic_task/: cat_basic_task.c
    ../../../catOS/src/core/schedule/static_prio_sched/: cat_bitmap.c cat_sp_task.c
    ../../../catOS/src/core/support/: cat_list.c
    ../../../catOS/test/: test_cat_string.c
